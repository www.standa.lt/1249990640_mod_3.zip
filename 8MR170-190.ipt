# Autodesk Inventor part: 8MR170-190
## iProperties
Created: 2008-10
Part Number: 8MR170-190
Document SubType Name: Modeling
Designer: Darius
Author: Darius
